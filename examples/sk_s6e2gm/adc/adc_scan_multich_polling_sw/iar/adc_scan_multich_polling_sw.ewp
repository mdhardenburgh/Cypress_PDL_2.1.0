# IAR project adc_scan_multich_polling_sw.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\..\..\..\devices\fm4\s6e2gmxj\common; ..\..\..\..\..\cmsis\include; ..\..\..\..\..\drivers; ..\..\..\..\..\utilities; ..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc_scan_multich_polling_sw.srec
  ILINK.IlinkOutputFile: adc_scan_multich_polling_sw.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\devices\fm4\s6e2gmxj\projects\iar\linker\s6e2gm8_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.FPU2: 0
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: ..\..\..\..\..\devices\fm4\s6e2gmxj\projects\iar\linker\s6e2gm8_rom.icf
  group common
    ../../../../../devices/fm4/s6e2gmxj/common/: system_s6e2gm.c
  group config
    ../: pdl_user.h
  group drivers
    ../../../../../drivers/: interrupts_fm0p.h interrupts_fm0p_type_1-a.c interrupts_fm0p_type_1-b.c interrupts_fm0p_type_2-a.c interrupts_fm0p_type_2-b.c interrupts_fm0p_type_3.c interrupts_fm3.h interrupts_fm3_type_a.c interrupts_fm3_type_b.c interrupts_fm3_type_c.c interrupts_fm4.h interrupts_fm4_type_a.c interrupts_fm4_type_b.c interrupts_fm4_type_c.c pdl.c pdl.h pdl_header.h
  group drivers/adc
    ../../../../../drivers/adc/: adc.c adc.h
  group drivers/bt
    ../../../../../drivers/bt/: bt.c bt.h
  group drivers/can
    ../../../../../drivers/can/: can.c can.h can_pre.c can_pre.h canfd.c canfd.h
  group drivers/clk
    ../../../../../drivers/clk/: clk.c clk.h
  group drivers/cr
    ../../../../../drivers/cr/: cr.c cr.h
  group drivers/crc
    ../../../../../drivers/crc/: crc.c crc.h
  group drivers/csv
    ../../../../../drivers/csv/: csv.c csv.h
  group drivers/dac
    ../../../../../drivers/dac/: dac.c dac.h
  group drivers/dma
    ../../../../../drivers/dma/: dma.c dma.h
  group drivers/dstc
    ../../../../../drivers/dstc/: dstc.c dstc.h
  group drivers/dt
    ../../../../../drivers/dt/: dt.c dt.h
  group drivers/exint
    ../../../../../drivers/exint/: exint.c exint.h
  group drivers/extif
    ../../../../../drivers/extif/: extif.c extif.h
  group drivers/flash
    ../../../../../drivers/flash/: dualflash.c dualflash.h mainflash.c mainflash.h workflash.c workflash.h
  group drivers/hbif
    ../../../../../drivers/hbif/: hbif.c hbif.h
  group drivers/hsspi
    ../../../../../drivers/hsspi/: hsspi.c hsspi.h
  group drivers/i2cs
    ../../../../../drivers/i2cs/: i2cs.c i2cs.h
  group drivers/i2s
    ../../../../../drivers/i2s/: i2s.c i2s.h
  group drivers/icc
    ../../../../../drivers/icc/: icc.c icc.h
  group drivers/lcd
    ../../../../../drivers/lcd/: lcd.c lcd.h
  group drivers/lpm
    ../../../../../drivers/lpm/: lpm.c lpm.h
  group drivers/lvd
    ../../../../../drivers/lvd/: lvd.c lvd.h
  group drivers/mfs
    ../../../../../drivers/mfs/: mfs.c mfs.h
  group drivers/mft
    ../../../../../drivers/mft/: mft_adcmp.c mft_adcmp.h mft_frt.c mft_frt.h mft_icu.c mft_icu.h mft_ocu.c mft_ocu.h mft_wfg.c mft_wfg.h
  group drivers/pcrc
    ../../../../../drivers/pcrc/: pcrc.c pcrc.h
  group drivers/ppg
    ../../../../../drivers/ppg/: ppg.c ppg.h
  group drivers/qprc
    ../../../../../drivers/qprc/: qprc.c qprc.h
  group drivers/rc
    ../../../../../drivers/rc/: rc.c rc.h
  group drivers/reset
    ../../../../../drivers/reset/: reset.c reset.h
  group drivers/rtc
    ../../../../../drivers/rtc/: rtc.c rtc.h
  group drivers/sdif
    ../../../../../drivers/sdif/: sdif.c sdif.h
  group drivers/uid
    ../../../../../drivers/uid/: uid.c uid.h
  group drivers/vbat
    ../../../../../drivers/vbat/: vbat.c vbat.h
  group drivers/wc
    ../../../../../drivers/wc/: wc.c wc.h
  group drivers/wdg
    ../../../../../drivers/wdg/: hwwdg.c hwwdg.h swwdg.c swwdg.h wdg.h
  group source
    ../: main.c
    ../../../../../devices/fm4/s6e2gmxj/projects/iar/: startup_s6e2gm.s
  group utilities
    ../../../../../utilities/printf_scanf/: uart_io.c
