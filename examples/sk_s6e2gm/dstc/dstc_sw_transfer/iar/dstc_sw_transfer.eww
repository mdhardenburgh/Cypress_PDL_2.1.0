<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\dstc_sw_transfer.ewp</path>
  </project>
  <batchBuild/>
</workspace>


