# Keil uVision project adc_scan_multich_polling_sw.uvprojx, settings and files
target Debug (ARM-ADS)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.4.5.0
  cpu: IRAM1(0x20000000,0xF000) IRAM2(0x2000F000,0x1000) IROM(0x0,0x8C000) CPUTYPE"(Cortex-M0+") CLOCK(-1) ELITTLE
  output: adc_scan_multich_polling_sw +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c include: ..\..\..\..\..\devices\fm0p\s6e1b8xf\common;..\..\..\..\..\cmsis\include;..\..\..\..\..\drivers;..\..\..\..\..\utilities;..\
  library: MicroLIB
  memory RVCT4: ROM 0x20000000 size 0x7800
  memory RVCT9: RAM 0x20007800 size 0x7800
  memory RVCT10: RAM 0x2000f000 size 0x1000
  scatter file: ..\..\..\..\..\devices\fm0p\s6e1b8xf\projects\mdk\linker\s6e1b86_ram.sct
  group common
    ../../../../../devices/fm0p/s6e1b8xf/common/: system_s6e1b8.c
  group source
    ../: main.c
    ../../../../../devices/fm0p/s6e1b8xf/projects/mdk/: startup_s6e1b8.s
  group config
    ../: pdl_user.h
  group drivers
    ../../../../../drivers/adc/: adc.c adc.h
    ../../../../../drivers/bt/: bt.c bt.h
    ../../../../../drivers/can/: can.c can.h can_pre.c can_pre.h canfd.c canfd.h
    ../../../../../drivers/clk/: clk.c clk.h
    ../../../../../drivers/cr/: cr.c cr.h
    ../../../../../drivers/crc/: crc.c crc.h
    ../../../../../drivers/csv/: csv.c csv.h
    ../../../../../drivers/dac/: dac.c dac.h
    ../../../../../drivers/dma/: dma.c dma.h
    ../../../../../drivers/dstc/: dstc.c dstc.h
    ../../../../../drivers/dt/: dt.c dt.h
    ../../../../../drivers/exint/: exint.c exint.h
    ../../../../../drivers/extif/: extif.c extif.h
    ../../../../../drivers/flash/: dualflash.c dualflash.h mainflash.c mainflash.h workflash.c workflash.h
    ../../../../../drivers/hbif/: hbif.c hbif.h
    ../../../../../drivers/hsspi/: hsspi.c hsspi.h
    ../../../../../drivers/i2cs/: i2cs.c i2cs.h
    ../../../../../drivers/i2s/: i2s.c i2s.h
    ../../../../../drivers/icc/: icc.c icc.h
    ../../../../../drivers/: interrupts_fm0p.h interrupts_fm0p_type_1-a.c interrupts_fm0p_type_1-b.c interrupts_fm0p_type_2-a.c interrupts_fm0p_type_2-b.c interrupts_fm0p_type_3.c interrupts_fm3.h interrupts_fm3_type_a.c interrupts_fm3_type_b.c interrupts_fm3_type_c.c interrupts_fm4.h interrupts_fm4_type_a.c interrupts_fm4_type_b.c interrupts_fm4_type_c.c pdl.c pdl.h pdl_header.h
    ../../../../../drivers/lcd/: lcd.c lcd.h
    ../../../../../drivers/lpm/: lpm.c lpm.h
    ../../../../../drivers/lvd/: lvd.c lvd.h
    ../../../../../drivers/mfs/: mfs.c mfs.h
    ../../../../../drivers/mft/: mft_adcmp.c mft_adcmp.h mft_frt.c mft_frt.h mft_icu.c mft_icu.h mft_ocu.c mft_ocu.h mft_wfg.c mft_wfg.h
    ../../../../../drivers/pcrc/: pcrc.c pcrc.h
    ../../../../../drivers/ppg/: ppg.c ppg.h
    ../../../../../drivers/qprc/: qprc.c qprc.h
    ../../../../../drivers/rc/: rc.c rc.h
    ../../../../../drivers/reset/: reset.c reset.h
    ../../../../../drivers/rtc/: rtc.c rtc.h
    ../../../../../drivers/sdif/: sdif.c sdif.h
    ../../../../../drivers/uid/: uid.c uid.h
    ../../../../../drivers/vbat/: vbat.c vbat.h
    ../../../../../drivers/wc/: wc.c wc.h
    ../../../../../drivers/wdg/: hwwdg.c hwwdg.h swwdg.c swwdg.h wdg.h
  group utilities
    ../../../../../utilities/printf_scanf/: uart_io.c
target Release (ARM-ADS)
  device: ARMCM0P ARM
  cpu: as above
  output: adc_scan_multich_polling_sw +hex
  c flags: Optim=4 v6Lang=1 v6LangP=1
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8c000
  memory RVCT9: RAM 0x20000000 size 0xf000
  memory RVCT10: RAM 0x2000f000 size 0x1000
  scatter file: ..\..\..\..\..\devices\fm0p\s6e1b8xf\projects\mdk\linker\s6e1b86_rom.sct
