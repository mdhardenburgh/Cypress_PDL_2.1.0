<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\wfg_rt_ppg_mode.ewp</path>
  </project>
  <batchBuild/>
</workspace>


