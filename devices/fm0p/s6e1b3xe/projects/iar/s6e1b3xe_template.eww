<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\s6e1b3xe_template.ewp</path>
  </project>
  <batchBuild/>
</workspace>


