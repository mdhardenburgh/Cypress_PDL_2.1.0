# Keil uVision project s6e1a1xc_template.uvprojx, settings and files
target S6E1A12_Debug (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IRAM1(0x20000000,0x1800) IROM(0x0,0x16000) CPUTYPE"(Cortex-M0+") CLOCK(-1) ELITTLE
  output: s6e1a1xc_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x20000000 size 0xC00
  memory RVCT9: RAM 0x20000C00 size 0xC00
  scatter file: .\linker\s6e1a12_ram.sct
  group common
    ../../common/: system_s6e1a1.c
  group source
    ../: main.c
    ./: startup_s6e1a1.s
target S6E1A12_Release (ARM-ADS)
  device: ARMCM0P ARM
  cpu: as above
  output: s6e1a1xc_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x16000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: .\linker\s6e1a12_rom.sct
target S6E1A11_Debug (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IRAM1(0x20000000,0x1800) IROM(0x0,0xE000) CPUTYPE"(Cortex-M0+") CLOCK(-1) ELITTLE
  output: s6e1a1xc_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x20000000 size 0xC00
  memory RVCT9: RAM 0x20000C00 size 0xC00
  scatter file: .\linker\s6e1a11_ram.sct
target S6E1A11_Release (ARM-ADS)
  device: ARMCM0P ARM
  cpu: as above
  output: s6e1a1xc_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0xE000
  memory RVCT9: RAM 0x20000000 size 0x1800
  scatter file: .\linker\s6e1a11_rom.sct
