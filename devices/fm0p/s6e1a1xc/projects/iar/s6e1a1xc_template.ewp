# IAR project s6e1a1xc_template.ewp, settings and files
configuration S6E1A12_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E1A12C  Spansion S6E1A12C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e1a1xc_template.srec
  ILINK.IlinkOutputFile: s6e1a1xc_template.out
  ILINK.IlinkIcfFile: linker\s6e1a12_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E1A12_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1a12_ram.icf
configuration S6E1A11_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E1A11C  Spansion S6E1A11C
  ILINK.IlinkIcfFile: linker\s6e1a11_rom.icf
configuration S6E1A11_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1a11_ram.icf
  group common
    ../../common/: system_s6e1a1.c
  group source
    ../: main.c
    ./: startup_s6e1a1.s
