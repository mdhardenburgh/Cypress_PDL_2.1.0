# Keil uVision project s6e1b8xe_template.uvprojx, settings and files
target S6E1B86_Debug (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IRAM1(0x20000000,0xF000) IRAM2(0x2000F000,0x1000) IROM(0x0,0x8C000) CPUTYPE"(Cortex-M0+") CLOCK(-1) ELITTLE
  output: s6e1b8xe_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x20000000 size 0x7800
  memory RVCT9: RAM 0x20007800 size 0x7800
  memory RVCT10: RAM 0x2000F000 size 0x1000
  scatter file: .\linker\s6e1b86_ram.sct
  group common
    ../../common/: system_s6e1b8.c
  group source
    ../: main.c
    ./: startup_s6e1b8.s
target S6E1B86_Release (ARM-ADS)
  device: ARMCM0P ARM
  cpu: as above
  output: s6e1b8xe_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x8C000
  memory RVCT9: RAM 0x20000000 size 0xF000
  memory RVCT10: RAM 0x2000F000 size 0x1000
  scatter file: .\linker\s6e1b86_rom.sct
target S6E1B84_Debug (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IRAM1(0x20008000,0x7000) IRAM2(0x2000F000,0x1000) IROM(0x0,0x4C000) CPUTYPE"(Cortex-M0+") CLOCK(-1) ELITTLE
  output: s6e1b8xe_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x20008000 size 0x3800
  memory RVCT9: RAM 0x2000B800 size 0x3800
  memory RVCT10: RAM 0x2000F000 size 0x1000
  scatter file: .\linker\s6e1b84_ram.sct
target S6E1B84_Release (ARM-ADS)
  device: ARMCM0P ARM
  cpu: as above
  output: s6e1b8xe_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x4C000
  memory RVCT9: RAM 0x20008000 size 0x7000
  memory RVCT10: RAM 0x2000F000 size 0x1000
  scatter file: .\linker\s6e1b84_rom.sct
