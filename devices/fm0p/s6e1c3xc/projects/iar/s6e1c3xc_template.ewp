# IAR project s6e1c3xc_template.ewp, settings and files
configuration S6E1C32_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E1C32C  Spansion S6E1C32C
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e1c3xc_template.srec
  ILINK.IlinkOutputFile: s6e1c3xc_template.out
  ILINK.IlinkIcfFile: linker\s6e1c32_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E1C32_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1c32_ram.icf
configuration S6E1C31_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E1C31C  Spansion S6E1C31C
  ILINK.IlinkIcfFile: linker\s6e1c31_rom.icf
configuration S6E1C31_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1c31_ram.icf
  group common
    ../../common/: system_s6e1c3.c
  group source
    ../: main.c
    ./: startup_s6e1c3.s
