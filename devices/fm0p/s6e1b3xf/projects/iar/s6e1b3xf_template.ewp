# IAR project s6e1b3xf_template.ewp, settings and files
configuration S6E1B36_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E1B36F  Spansion S6E1B36F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e1b3xf_template.srec
  ILINK.IlinkOutputFile: s6e1b3xf_template.out
  ILINK.IlinkIcfFile: linker\s6e1b36_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E1B36_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1b36_ram.icf
configuration S6E1B34_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E1B34F  Spansion S6E1B34F
  ILINK.IlinkIcfFile: linker\s6e1b34_rom.icf
configuration S6E1B34_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1b34_ram.icf
  group common
    ../../common/: system_s6e1b3.c
  group source
    ../: main.c
    ./: startup_s6e1b3.s
