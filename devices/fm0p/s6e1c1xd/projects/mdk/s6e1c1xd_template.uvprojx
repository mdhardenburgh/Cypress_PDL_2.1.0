# Keil uVision project s6e1c1xd_template.uvprojx, settings and files
target S6E1C12_Debug (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IRAM1(0x20000000,0x3000) IRAM2(0x20003000,0x1000) IROM(0x0,0x1FFF0) CPUTYPE"(Cortex-M0+") CLOCK(-1) ELITTLE
  output: s6e1c1xd_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x20000000 size 0x1800
  memory RVCT9: RAM 0x20001800 size 0x1800
  memory RVCT10: RAM 0x20003000 size 0x1000
  scatter file: .\linker\s6e1c12_ram.sct
  group common
    ../../common/: system_s6e1c1.c
  group source
    ../: main.c
    ./: startup_s6e1c1.s
target S6E1C12_Release (ARM-ADS)
  device: ARMCM0P ARM
  cpu: as above
  output: s6e1c1xd_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x1FFF0
  memory RVCT9: RAM 0x20000000 size 0x3000
  memory RVCT10: RAM 0x20003000 size 0x1000
  scatter file: .\linker\s6e1c12_rom.sct
target S6E1C11_Debug (ARM-ADS)
  device: ARMCM0P ARM
  cpu: IRAM1(0x20001000,0x2000) IRAM2(0x20003000,0x1000) IROM(0x0,0xFFF0) CPUTYPE"(Cortex-M0+") CLOCK(-1) ELITTLE
  output: s6e1c1xd_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x20001000 size 0x1000
  memory RVCT9: RAM 0x20002000 size 0x1000
  memory RVCT10: RAM 0x20003000 size 0x1000
  scatter file: .\linker\s6e1c11_ram.sct
target S6E1C11_Release (ARM-ADS)
  device: ARMCM0P ARM
  cpu: as above
  output: s6e1c1xd_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0xFFF0
  memory RVCT9: RAM 0x20001000 size 0x2000
  memory RVCT10: RAM 0x20003000 size 0x1000
  scatter file: .\linker\s6e1c11_rom.sct
