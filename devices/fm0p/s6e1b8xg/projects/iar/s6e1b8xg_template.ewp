# IAR project s6e1b8xg_template.ewp, settings and files
configuration S6E1B86_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E1B86G  Spansion S6E1B86G
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e1b8xg_template.srec
  ILINK.IlinkOutputFile: s6e1b8xg_template.out
  ILINK.IlinkIcfFile: linker\s6e1b86_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E1B86_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1b86_ram.icf
configuration S6E1B84_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E1B84G  Spansion S6E1B84G
  ILINK.IlinkIcfFile: linker\s6e1b84_rom.icf
configuration S6E1B84_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e1b84_ram.icf
  group common
    ../../common/: system_s6e1b8.c
  group source
    ../: main.c
    ./: startup_s6e1b8.s
