# IAR project s6e2hexf_template.ewp, settings and files
configuration S6E2HE6_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2HE6F  Spansion S6E2HE6F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2hexf_template.srec
  ILINK.IlinkOutputFile: s6e2hexf_template.out
  ILINK.IlinkIcfFile: linker\s6e2he6_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2HE6_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2he6_ram.icf
configuration S6E2HE4_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2HE4F  Spansion S6E2HE4F
  ILINK.IlinkIcfFile: linker\s6e2he4_rom.icf
configuration S6E2HE4_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2he4_ram.icf
  group common
    ../../common/: system_s6e2he.c
  group source
    ../: main.c
    ./: startup_s6e2he.s
