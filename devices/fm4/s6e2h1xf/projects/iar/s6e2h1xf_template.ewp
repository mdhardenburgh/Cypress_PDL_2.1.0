# IAR project s6e2h1xf_template.ewp, settings and files
configuration S6E2H16_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2H16F  Spansion S6E2H16F
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2h1xf_template.srec
  ILINK.IlinkOutputFile: s6e2h1xf_template.out
  ILINK.IlinkIcfFile: linker\s6e2h16_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2H16_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2h16_ram.icf
configuration S6E2H14_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2H14F  Spansion S6E2H14F
  ILINK.IlinkIcfFile: linker\s6e2h14_rom.icf
configuration S6E2H14_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2h14_ram.icf
  group common
    ../../common/: system_s6e2h1.c
  group source
    ../: main.c
    ./: startup_s6e2h1.s
