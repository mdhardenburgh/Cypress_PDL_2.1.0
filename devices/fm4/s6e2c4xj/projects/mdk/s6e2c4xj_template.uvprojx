# Keil uVision project s6e2c4xj_template.uvprojx, settings and files
target S6E2C4A_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFD0000,0x30000) IRAM2(0x20038000,0x10000) IROM(0x0,0x200000) IROM2(0x406000,0xA000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2c4xj_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFD0000 size 0x18000
  memory RVCT5: ROM 0x406000 size 0xA000
  memory RVCT9: RAM 0x1FFE8000 size 0x18000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2c4a_ram.sct
  group common
    ../../common/: system_s6e2c4.c
  group source
    ../: main.c
    ./: startup_s6e2c4.s
target S6E2C4A_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2c4xj_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x200000
  memory RVCT5: ROM 0x406000 size 0xA000
  memory RVCT9: RAM 0x1FFD0000 size 0x30000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2c4a_rom.sct
target S6E2C49_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFE0000,0x20000) IRAM2(0x20038000,0x10000) IROM(0x0,0x180000) IROM2(0x406000,0xA000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2c4xj_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFE0000 size 0x10000
  memory RVCT5: ROM 0x406000 size 0xA000
  memory RVCT9: RAM 0x1FFF0000 size 0x10000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2c49_ram.sct
target S6E2C49_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2c4xj_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x180000
  memory RVCT5: ROM 0x406000 size 0xA000
  memory RVCT9: RAM 0x1FFE0000 size 0x20000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2c49_rom.sct
target S6E2C48_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFF0000,0x10000) IRAM2(0x20038000,0x10000) IROM(0x0,0x100000) IROM2(0x406000,0xA000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2c4xj_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFF0000 size 0x8000
  memory RVCT5: ROM 0x406000 size 0xA000
  memory RVCT9: RAM 0x1FFF8000 size 0x8000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2c48_ram.sct
target S6E2C48_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2c4xj_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x406000 size 0xA000
  memory RVCT9: RAM 0x1FFF0000 size 0x10000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\s6e2c48_rom.sct
