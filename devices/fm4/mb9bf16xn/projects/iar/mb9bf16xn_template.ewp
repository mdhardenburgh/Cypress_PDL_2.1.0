# IAR project mb9bf16xn_template.ewp, settings and files
configuration MB9B168_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B168N  Spansion MB9B168N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf16xn_template.srec
  ILINK.IlinkOutputFile: mb9bf16xn_template.out
  ILINK.IlinkIcfFile: linker\mb9b168_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B168_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b168_ram.icf
configuration MB9B167_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B167N  Spansion MB9B167N
  ILINK.IlinkIcfFile: linker\mb9b167_rom.icf
configuration MB9B167_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b167_ram.icf
configuration MB9B166_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B166N  Spansion MB9B166N
  ILINK.IlinkIcfFile: linker\mb9b166_rom.icf
configuration MB9B166_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b166_ram.icf
  group common
    ../../common/: system_mb9b160r.c
  group source
    ../: main.c
    ./: startup_mb9b160r.s
