# IAR project s6e2dfxg_template.ewp, settings and files
configuration S6E2DF5_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2DF5G  Spansion S6E2DF5G
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2dfxg_template.srec
  ILINK.IlinkOutputFile: s6e2dfxg_template.out
  ILINK.IlinkIcfFile: linker\s6e2df5_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2DF5_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2df5_ram.icf
  group common
    ../../common/: system_s6e2df.c
  group source
    ../: main.c
    ./: startup_s6e2df.s
