# IAR project s6e2gmxh_template.ewp, settings and files
configuration S6E2GM8_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2GM8H  Spansion S6E2GM8H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2gmxh_template.srec
  ILINK.IlinkOutputFile: s6e2gmxh_template.out
  ILINK.IlinkIcfFile: linker\s6e2gm8_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2GM8_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2gm8_ram.icf
configuration S6E2GM6_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2GM6H  Spansion S6E2GM6H
  ILINK.IlinkIcfFile: linker\s6e2gm6_rom.icf
configuration S6E2GM6_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2gm6_ram.icf
  group common
    ../../common/: system_s6e2gm.c
  group source
    ../: main.c
    ./: startup_s6e2gm.s
