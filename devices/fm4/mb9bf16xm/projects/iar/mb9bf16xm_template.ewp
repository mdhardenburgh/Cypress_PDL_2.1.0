# IAR project mb9bf16xm_template.ewp, settings and files
configuration MB9B168_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B168M  Spansion MB9B168M
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf16xm_template.srec
  ILINK.IlinkOutputFile: mb9bf16xm_template.out
  ILINK.IlinkIcfFile: linker\mb9b168_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B168_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b168_ram.icf
configuration MB9B167_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B167M  Spansion MB9B167M
  ILINK.IlinkIcfFile: linker\mb9b167_rom.icf
configuration MB9B167_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b167_ram.icf
configuration MB9B166_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B166M  Spansion MB9B166M
  ILINK.IlinkIcfFile: linker\mb9b166_rom.icf
configuration MB9B166_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b166_ram.icf
  group common
    ../../common/: system_mb9b160r.c
  group source
    ../: main.c
    ./: startup_mb9b160r.s
