# IAR project mb9bf16xl_template.ewp, settings and files
configuration MB9B166_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B166L  Spansion MB9B166L
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf16xl_template.srec
  ILINK.IlinkOutputFile: mb9bf16xl_template.out
  ILINK.IlinkIcfFile: linker\mb9b166_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B166_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b166_ram.icf
configuration MB9B165_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B165L  Spansion MB9B165L
  ILINK.IlinkIcfFile: linker\mb9b165_rom.icf
configuration MB9B165_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b165_ram.icf
configuration MB9B164_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B164L  Spansion MB9B164L
  ILINK.IlinkIcfFile: linker\mb9b164_rom.icf
configuration MB9B164_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b164_ram.icf
  group common
    ../../common/: system_mb9b160l.c
  group source
    ../: main.c
    ./: startup_mb9b160l.s
