# IAR project mb9bf36xr_template.ewp, settings and files
configuration MB9B368_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B368R  Spansion MB9B368R
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf36xr_template.srec
  ILINK.IlinkOutputFile: mb9bf36xr_template.out
  ILINK.IlinkIcfFile: linker\mb9b368_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B368_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b368_ram.icf
configuration MB9B367_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B367R  Spansion MB9B367R
  ILINK.IlinkIcfFile: linker\mb9b367_rom.icf
configuration MB9B367_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b367_ram.icf
configuration MB9B366_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B366R  Spansion MB9B366R
  ILINK.IlinkIcfFile: linker\mb9b366_rom.icf
configuration MB9B366_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b366_ram.icf
  group common
    ../../common/: system_mb9b360r.c
  group source
    ../: main.c
    ./: startup_mb9b360r.s
