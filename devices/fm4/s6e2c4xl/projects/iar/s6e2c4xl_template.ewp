# IAR project s6e2c4xl_template.ewp, settings and files
configuration S6E2C4A_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2C4AL  Spansion S6E2C4AL
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2c4xl_template.srec
  ILINK.IlinkOutputFile: s6e2c4xl_template.out
  ILINK.IlinkIcfFile: linker\s6e2c4a_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2C4A_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c4a_ram.icf
configuration S6E2C49_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C49L  Spansion S6E2C49L
  ILINK.IlinkIcfFile: linker\s6e2c49_rom.icf
configuration S6E2C49_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c49_ram.icf
configuration S6E2C48_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C48L  Spansion S6E2C48L
  ILINK.IlinkIcfFile: linker\s6e2c48_rom.icf
configuration S6E2C48_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c48_ram.icf
  group common
    ../../common/: system_s6e2c4.c
  group source
    ../: main.c
    ./: startup_s6e2c4.s
