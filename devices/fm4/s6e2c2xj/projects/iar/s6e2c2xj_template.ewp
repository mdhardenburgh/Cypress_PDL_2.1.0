# IAR project s6e2c2xj_template.ewp, settings and files
configuration S6E2C2A_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2C2AJ  Spansion S6E2C2AJ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2c2xj_template.srec
  ILINK.IlinkOutputFile: s6e2c2xj_template.out
  ILINK.IlinkIcfFile: linker\s6e2c2a_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2C2A_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c2a_ram.icf
configuration S6E2C29_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C29J  Spansion S6E2C29J
  ILINK.IlinkIcfFile: linker\s6e2c29_rom.icf
configuration S6E2C29_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c29_ram.icf
configuration S6E2C28_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C28J  Spansion S6E2C28J
  ILINK.IlinkIcfFile: linker\s6e2c28_rom.icf
configuration S6E2C28_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c28_ram.icf
  group common
    ../../common/: system_s6e2c2.c
  group source
    ../: main.c
    ./: startup_s6e2c2.s
