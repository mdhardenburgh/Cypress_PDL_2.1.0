# Keil uVision project s6e2d3xj_template.uvprojx, settings and files
target S6E2D35_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFF8000,0x8000) IRAM2(0x20040000,0x1000) IROM(0x0,0x60000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2d3xj_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFF8000 size 0x4000
  memory RVCT9: RAM 0x1FFFC000 size 0x4000
  memory RVCT10: RAM 0x20040000 size 0x1000
  scatter file: .\linker\s6e2d35_ram.sct
  group common
    ../../common/: system_s6e2d3.c
  group source
    ../: main.c
    ./: startup_s6e2d3.s
target S6E2D35_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2d3xj_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT9: RAM 0x1FFF8000 size 0x8000
  memory RVCT10: RAM 0x20040000 size 0x1000
  scatter file: .\linker\s6e2d35_rom.sct
