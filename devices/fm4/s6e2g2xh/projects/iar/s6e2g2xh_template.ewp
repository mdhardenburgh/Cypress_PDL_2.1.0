# IAR project s6e2g2xh_template.ewp, settings and files
configuration S6E2G28_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2G28H  Spansion S6E2G28H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2g2xh_template.srec
  ILINK.IlinkOutputFile: s6e2g2xh_template.out
  ILINK.IlinkIcfFile: linker\s6e2g28_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2G28_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2g28_ram.icf
configuration S6E2G26_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2G26H  Spansion S6E2G26H
  ILINK.IlinkIcfFile: linker\s6e2g26_rom.icf
configuration S6E2G26_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2g26_ram.icf
  group common
    ../../common/: system_s6e2g2.c
  group source
    ../: main.c
    ./: startup_s6e2g2.s
