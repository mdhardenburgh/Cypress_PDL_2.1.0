# IAR project mb9bf56xn_template.ewp, settings and files
configuration MB9B568_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B568N  Spansion MB9B568N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf56xn_template.srec
  ILINK.IlinkOutputFile: mb9bf56xn_template.out
  ILINK.IlinkIcfFile: linker\mb9b568_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B568_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b568_ram.icf
configuration MB9B567_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B567N  Spansion MB9B567N
  ILINK.IlinkIcfFile: linker\mb9b567_rom.icf
configuration MB9B567_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b567_ram.icf
configuration MB9B566_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B566N  Spansion MB9B566N
  ILINK.IlinkIcfFile: linker\mb9b566_rom.icf
configuration MB9B566_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b566_ram.icf
  group common
    ../../common/: system_mb9b560r.c
  group source
    ../: main.c
    ./: startup_mb9b560r.s
