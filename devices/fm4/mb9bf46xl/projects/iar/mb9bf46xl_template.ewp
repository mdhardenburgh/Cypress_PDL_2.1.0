# IAR project mb9bf46xl_template.ewp, settings and files
configuration MB9B466_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B466L  Spansion MB9B466L
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf46xl_template.srec
  ILINK.IlinkOutputFile: mb9bf46xl_template.out
  ILINK.IlinkIcfFile: linker\mb9b466_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B466_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b466_ram.icf
configuration MB9B465_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B465L  Spansion MB9B465L
  ILINK.IlinkIcfFile: linker\mb9b465_rom.icf
configuration MB9B465_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b465_ram.icf
configuration MB9B464_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B464L  Spansion MB9B464L
  ILINK.IlinkIcfFile: linker\mb9b464_rom.icf
configuration MB9B464_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b464_ram.icf
  group common
    ../../common/: system_mb9b460l.c
  group source
    ../: main.c
    ./: startup_mb9b460l.s
