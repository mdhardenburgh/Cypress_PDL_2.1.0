# Keil uVision project mb9bf46xr_template.uvprojx, settings and files
target MB9B468_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFF0000,0x10000) IRAM2(0x20038000,0x10000) IROM(0x0,0x100000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: mb9bf46xr_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFF0000 size 0x8000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFF8000 size 0x8000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\mb9b468_ram.sct
  group common
    ../../common/: system_mb9b460r.c
  group source
    ../: main.c
    ./: startup_mb9b460r.s
target MB9B468_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: mb9bf46xr_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFF0000 size 0x10000
  memory RVCT10: RAM 0x20038000 size 0x10000
  scatter file: .\linker\mb9b468_rom.sct
target MB9B467_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFF4000,0xC000) IRAM2(0x2003A000,0xC000) IROM(0x0,0xC0000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: mb9bf46xr_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFF4000 size 0x6000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFFA000 size 0x6000
  memory RVCT10: RAM 0x2003A000 size 0xC000
  scatter file: .\linker\mb9b467_ram.sct
target MB9B467_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: mb9bf46xr_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0xC0000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFF4000 size 0xC000
  memory RVCT10: RAM 0x2003A000 size 0xC000
  scatter file: .\linker\mb9b467_rom.sct
target MB9B466_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFF8000,0x8000) IRAM2(0x2003C000,0x8000) IROM(0x0,0x80000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: mb9bf46xr_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFF8000 size 0x4000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFFC000 size 0x4000
  memory RVCT10: RAM 0x2003C000 size 0x8000
  scatter file: .\linker\mb9b466_ram.sct
target MB9B466_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: mb9bf46xr_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFF8000 size 0x8000
  memory RVCT10: RAM 0x2003C000 size 0x8000
  scatter file: .\linker\mb9b466_rom.sct
