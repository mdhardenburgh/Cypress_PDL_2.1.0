# IAR project s6e2gkxh_template.ewp, settings and files
configuration S6E2GK8_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2GK8H  Spansion S6E2GK8H
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2gkxh_template.srec
  ILINK.IlinkOutputFile: s6e2gkxh_template.out
  ILINK.IlinkIcfFile: linker\s6e2gk8_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2GK8_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2gk8_ram.icf
configuration S6E2GK6_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2GK6H  Spansion S6E2GK6H
  ILINK.IlinkIcfFile: linker\s6e2gk6_rom.icf
configuration S6E2GK6_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2gk6_ram.icf
  group common
    ../../common/: system_s6e2gk.c
  group source
    ../: main.c
    ./: startup_s6e2gk.s
