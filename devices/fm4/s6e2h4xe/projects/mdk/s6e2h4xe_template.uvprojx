# Keil uVision project s6e2h4xe_template.uvprojx, settings and files
target S6E2H46_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFF8000,0x8000) IRAM2(0x2003C000,0x8000) IROM(0x0,0x80000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2h4xe_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFF8000 size 0x4000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFFC000 size 0x4000
  memory RVCT10: RAM 0x2003C000 size 0x8000
  scatter file: .\linker\s6e2h46_ram.sct
  group common
    ../../common/: system_s6e2h4.c
  group source
    ../: main.c
    ./: startup_s6e2h4.s
target S6E2H46_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2h4xe_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFF8000 size 0x8000
  memory RVCT10: RAM 0x2003C000 size 0x8000
  scatter file: .\linker\s6e2h46_rom.sct
target S6E2H44_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x1FFFC000,0x4000) IRAM2(0x2003E000,0x4000) IROM(0x0,0x40000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: s6e2h4xe_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x1FFFC000 size 0x2000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFFE000 size 0x2000
  memory RVCT10: RAM 0x2003E000 size 0x4000
  scatter file: .\linker\s6e2h44_ram.sct
target S6E2H44_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: s6e2h4xe_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x1FFFC000 size 0x4000
  memory RVCT10: RAM 0x2003E000 size 0x4000
  scatter file: .\linker\s6e2h44_rom.sct
