# IAR project s6e2c1xh_template.ewp, settings and files
configuration S6E2C1A_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2C1AH  Spansion S6E2C1AH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2c1xh_template.srec
  ILINK.IlinkOutputFile: s6e2c1xh_template.out
  ILINK.IlinkIcfFile: linker\s6e2c1a_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2C1A_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c1a_ram.icf
configuration S6E2C19_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C19H  Spansion S6E2C19H
  ILINK.IlinkIcfFile: linker\s6e2c19_rom.icf
configuration S6E2C19_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c19_ram.icf
configuration S6E2C18_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C18H  Spansion S6E2C18H
  ILINK.IlinkIcfFile: linker\s6e2c18_rom.icf
configuration S6E2C18_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c18_ram.icf
  group common
    ../../common/: system_s6e2c1.c
  group source
    ../: main.c
    ./: startup_s6e2c1.s
