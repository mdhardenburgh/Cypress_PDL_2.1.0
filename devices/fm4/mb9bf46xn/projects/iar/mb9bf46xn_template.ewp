# IAR project mb9bf46xn_template.ewp, settings and files
configuration MB9B468_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B468N  Spansion MB9B468N
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf46xn_template.srec
  ILINK.IlinkOutputFile: mb9bf46xn_template.out
  ILINK.IlinkIcfFile: linker\mb9b468_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B468_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b468_ram.icf
configuration MB9B467_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B467N  Spansion MB9B467N
  ILINK.IlinkIcfFile: linker\mb9b467_rom.icf
configuration MB9B467_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b467_ram.icf
configuration MB9B466_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B466N  Spansion MB9B466N
  ILINK.IlinkIcfFile: linker\mb9b466_rom.icf
configuration MB9B466_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b466_ram.icf
  group common
    ../../common/: system_mb9b460r.c
  group source
    ../: main.c
    ./: startup_mb9b460r.s
