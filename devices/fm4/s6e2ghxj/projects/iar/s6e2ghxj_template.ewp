# IAR project s6e2ghxj_template.ewp, settings and files
configuration S6E2GH8_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2GH8J  Spansion S6E2GH8J
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2ghxj_template.srec
  ILINK.IlinkOutputFile: s6e2ghxj_template.out
  ILINK.IlinkIcfFile: linker\s6e2gh8_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2GH8_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2gh8_ram.icf
configuration S6E2GH6_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2GH6J  Spansion S6E2GH6J
  ILINK.IlinkIcfFile: linker\s6e2gh6_rom.icf
configuration S6E2GH6_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2gh6_ram.icf
  group common
    ../../common/: system_s6e2gh.c
  group source
    ../: main.c
    ./: startup_s6e2gh.s
