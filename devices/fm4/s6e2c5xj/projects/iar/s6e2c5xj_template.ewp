# IAR project s6e2c5xj_template.ewp, settings and files
configuration S6E2C5A_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2C5AJ  Spansion S6E2C5AJ
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2c5xj_template.srec
  ILINK.IlinkOutputFile: s6e2c5xj_template.out
  ILINK.IlinkIcfFile: linker\s6e2c5a_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2C5A_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c5a_ram.icf
configuration S6E2C59_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C59J  Spansion S6E2C59J
  ILINK.IlinkIcfFile: linker\s6e2c59_rom.icf
configuration S6E2C59_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c59_ram.icf
configuration S6E2C58_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C58J  Spansion S6E2C58J
  ILINK.IlinkIcfFile: linker\s6e2c58_rom.icf
configuration S6E2C58_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c58_ram.icf
  group common
    ../../common/: system_s6e2c5.c
  group source
    ../: main.c
    ./: startup_s6e2c5.s
