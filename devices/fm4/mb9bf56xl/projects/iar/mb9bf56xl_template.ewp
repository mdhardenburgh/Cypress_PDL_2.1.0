# IAR project mb9bf56xl_template.ewp, settings and files
configuration MB9B566_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B566L  Spansion MB9B566L
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf56xl_template.srec
  ILINK.IlinkOutputFile: mb9bf56xl_template.out
  ILINK.IlinkIcfFile: linker\mb9b566_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B566_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b566_ram.icf
configuration MB9B565_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B565L  Spansion MB9B565L
  ILINK.IlinkIcfFile: linker\mb9b565_rom.icf
configuration MB9B565_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b565_ram.icf
configuration MB9B564_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B564L  Spansion MB9B564L
  ILINK.IlinkIcfFile: linker\mb9b564_rom.icf
configuration MB9B564_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b564_ram.icf
  group common
    ../../common/: system_mb9b560l.c
  group source
    ../: main.c
    ./: startup_mb9b560l.s
