# IAR project s6e2c3xl_template.ewp, settings and files
configuration S6E2C3A_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2C3AL  Spansion S6E2C3AL
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2c3xl_template.srec
  ILINK.IlinkOutputFile: s6e2c3xl_template.out
  ILINK.IlinkIcfFile: linker\s6e2c3a_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2C3A_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c3a_ram.icf
configuration S6E2C39_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C39L  Spansion S6E2C39L
  ILINK.IlinkIcfFile: linker\s6e2c39_rom.icf
configuration S6E2C39_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c39_ram.icf
configuration S6E2C38_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2C38L  Spansion S6E2C38L
  ILINK.IlinkIcfFile: linker\s6e2c38_rom.icf
configuration S6E2C38_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2c38_ram.icf
  group common
    ../../common/: system_s6e2c3.c
  group source
    ../: main.c
    ./: startup_s6e2c3.s
