# IAR project s6e2ccxh_template.ewp, settings and files
configuration S6E2CCA_Release (ARM, debug)
  General.OGChipSelectEditMenu: S6E2CCAH  Spansion S6E2CCAH
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: s6e2ccxh_template.srec
  ILINK.IlinkOutputFile: s6e2ccxh_template.out
  ILINK.IlinkIcfFile: linker\s6e2cca_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration S6E2CCA_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2cca_ram.icf
configuration S6E2CC9_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2CC9H  Spansion S6E2CC9H
  ILINK.IlinkIcfFile: linker\s6e2cc9_rom.icf
configuration S6E2CC9_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2cc9_ram.icf
configuration S6E2CC8_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: S6E2CC8H  Spansion S6E2CC8H
  ILINK.IlinkIcfFile: linker\s6e2cc8_rom.icf
configuration S6E2CC8_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\s6e2cc8_ram.icf
  group common
    ../../common/: system_s6e2cc.c
  group source
    ../: main.c
    ./: startup_s6e2cc.s
