# Keil uVision project mb9bf36xl_template.uvprojx, settings and files
target MB9B366_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x2003C000,0x8000) IRAM2(0x1FFF8000,0x8000) IROM(0x0,0x80000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: mb9bf36xl_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x2003C000 size 0x4000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x20040000 size 0x4000
  memory RVCT10: RAM 0x1FFF8000 size 0x8000
  scatter file: .\linker\mb9b366_ram.sct
  group common
    ../../common/: system_mb9b360l.c
  group source
    ../: main.c
    ./: startup_mb9b360l.s
target MB9B366_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: mb9bf36xl_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x2003C000 size 0x8000
  memory RVCT10: RAM 0x1FFF8000 size 0x8000
  scatter file: .\linker\mb9b366_rom.sct
target MB9B365_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x2003D000,0x6000) IRAM2(0x1FFFA000,0x6000) IROM(0x0,0x60000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: mb9bf36xl_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x2003D000 size 0x3000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x20040000 size 0x3000
  memory RVCT10: RAM 0x1FFFA000 size 0x6000
  scatter file: .\linker\mb9b365_ram.sct
target MB9B365_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: mb9bf36xl_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x60000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x2003D000 size 0x6000
  memory RVCT10: RAM 0x1FFFA000 size 0x6000
  scatter file: .\linker\mb9b365_rom.sct
target MB9B364_Debug (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: IRAM1(0x2003E000,0x4000) IRAM2(0x1FFFC000,0x4000) IROM(0x0,0x40000) IROM2(0x200C0000,0x8000) CPUTYPE"(Cortex-M4") FPU2 CLOCK(-1) ELITTLE
  output: mb9bf36xl_template +hex
  c flags: Optim=1
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x2003E000 size 0x2000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x20040000 size 0x2000
  memory RVCT10: RAM 0x1FFFC000 size 0x4000
  scatter file: .\linker\mb9b364_ram.sct
target MB9B364_Release (ARM-ADS)
  device: ARMCM4_FP ARM
  cpu: as above
  output: mb9bf36xl_template +hex
  c flags: Optim=4
  c include: ..\..\common;..\..\..\..\..\cmsis\include;
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT5: ROM 0x200C0000 size 0x8000
  memory RVCT9: RAM 0x2003E000 size 0x4000
  memory RVCT10: RAM 0x1FFFC000 size 0x4000
  scatter file: .\linker\mb9b364_rom.sct
