# IAR project mb9bf36xl_template.ewp, settings and files
configuration MB9B366_Release (ARM, debug)
  General.OGChipSelectEditMenu: MB9B366L  Spansion MB9B366L
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\common; ..\..\..\..\..\cmsis\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mb9bf36xl_template.srec
  ILINK.IlinkOutputFile: mb9bf36xl_template.out
  ILINK.IlinkIcfFile: linker\mb9b366_rom.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MB9B366_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b366_ram.icf
configuration MB9B365_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B365L  Spansion MB9B365L
  ILINK.IlinkIcfFile: linker\mb9b365_rom.icf
configuration MB9B365_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b365_ram.icf
configuration MB9B364_Release (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9B364L  Spansion MB9B364L
  ILINK.IlinkIcfFile: linker\mb9b364_rom.icf
configuration MB9B364_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: MB9BF566R Spansion MB9BF566R
  ICCARM.CCOptLevel: 0
  ILINK.IlinkIcfFile: linker\mb9b364_ram.icf
  group common
    ../../common/: system_mb9b360l.c
  group source
    ../: main.c
    ./: startup_mb9b360l.s
